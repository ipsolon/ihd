options:
  parameters:
    generate_options: qt_gui
    id: ChameleonFFT
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rec_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: rec_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: rec_len
    type: complex
  states: {}
- name: chameleon_chameleon_fft_0
  id: chameleon_chameleon_fft
  parameters:
    center_freq: '2450000000'
    ip_addr: 10.75.42.208
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: rec_len
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_complex_to_mag_0, '0']
- [chameleon_chameleon_fft_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
