options:
  parameters:
    generate_options: qt_gui
    id: chameleon_fft
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rec_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: rec_len
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: rec_len
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: rec_len
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/isrp_samples_gnuradio.dat
    type: complex
    vlen: rec_len
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '.000976562'
    type: complex
    vlen: rec_len
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: rec_len
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: rec_len
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: rec_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: rec_len
    type: complex
  states: {}
- name: ihd_chameleon_0
  id: ihd_chameleon
  parameters:
    center_freq: '6000000000'
    ip_addr: 192.168.10.200
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    name: '"Multiplied"'
    vlen: rec_len
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    name: '"No Fast Multiply"'
    vlen: rec_len
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Conj"'
    vlen: rec_len
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_complex_to_mag_squared_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_complex_to_real_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_xx_0, '0']
- [ihd_chameleon_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
