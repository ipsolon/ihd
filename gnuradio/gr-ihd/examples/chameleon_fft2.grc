options:
  parameters:
    generate_options: qt_gui
    id: chameleon_fft2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rec_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: rec_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: rec_len
    type: float
  states: {}
- name: ihd_chameleon_fft_0
  id: ihd_chameleon_fft
  parameters:
    center_freq: '6000000000'
    ip_addr: 127.0.0.1
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    vlen: rec_len
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_nlog10_ff_0, '0']
- [ihd_chameleon_fft_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
