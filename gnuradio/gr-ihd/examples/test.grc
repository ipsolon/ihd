options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ihd_ihd_source_0
  id: ihd_ihd_source
  parameters:
    center_freq: '6000000000'
    ip_addr: 127.0.0.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}

connections:
- [ihd_ihd_source_0, '0', qtgui_freq_sink_x_0, '0']
- [ihd_ihd_source_0, '0', qtgui_time_sink_x_0, '0']
- [ihd_ihd_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
