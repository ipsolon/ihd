options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: ihd_ihd_source_0
  id: ihd_ihd_source
  parameters:
    center_freq: '6000000000'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [ihd_ihd_source_0, '0', blocks_float_to_complex_0, '0']
- [ihd_ihd_source_0, '0', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
